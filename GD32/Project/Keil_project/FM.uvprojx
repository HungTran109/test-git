# Keil uVision project FM.uvprojx, settings and files
target GD32E23x (6140000::V6.14::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: FM_GD32E230 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230,APP_BTN_MAX_BTN_SUPPORT=3,APP_MAX_LED_SUPPORT=3
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include;..\..\..\Gateway\esp32\components\app_btn\include;..\app_cli;..\..\..\Gateway\esp32\components\app_led_status\include;..\..\..\Gateway\esp32\components\app_spi\include;..\..\..\Gateway\esp32\components\lora\include;..\..\..\Gateway\esp32\components\systime\include;..\inc;..\..\..\Gateway\esp32\components\board_hw\include;..\..\..\Gateway\esp32\components\app_debug;..\..\..\Gateway\esp32\components\SEGGER_RTT_V680a\RTT;..\lwrb\lwrb\src\include;..\board_hw\include;..\porting;..\porting\SEGGER_RTT_V698b\RTT;..\porting\app_debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: gd32e23x_it.c main.c systick.c
    ../inc/: sdkconfig.h app_wdt.h
    ../src/: app_wdt.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group components
    ../board_hw/: board_hw.c
    ../board_hw/include/: board_hw.h
  group porting
    ../porting/: ESP32DataLayer.c Utilities.c DriverUART.c Debug.c HardwareManager.c InitSystem.c Button.c I2CFM.c Led7.c InternalFlash.c GPS.c GPS.h GPSUtils.c
  group SeggerRTT
    ../porting/SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group lwrb
    ../lwrb/lwrb/src/lwrb/: lwrb.c
    ../lwrb/lwrb/src/include/lwrb/: lwrb.h
  group app_debug
    ../porting/app_debug/: app_debug.c app_debug.h
software components: CMSIS:CORE 5.0.2
